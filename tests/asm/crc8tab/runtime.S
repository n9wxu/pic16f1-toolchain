; crc8tab: CRC-8 through a 256-entry table in flash, of "123456789" and of
; the table itself. See tests/programs/crc8tab/main.c.
;
; The C program computes the CRC of the table four times and folds each
; into b. The four are the same number, so it is computed once here (LLVM
; does the same); the folding is done four times as written.
#include "bench.inc"

#define CRC 0x70
#define AL  0x74            /* results as 16-bit values: high bytes zero; */
#define AH  0x75            /* the first printed uppermost */
#define BL  0x72
#define BH  0x73
#define N   0x76

    bench_start
    point_fsr0 check
    movlw   9
    call    crc8
    movwf   AL
    clrf    AH

    point_fsr0 table
    movlw   255
    call    crc8
    clrf    BL              ; b = ((((0 ^ c) + 0) ^ c) + 1 ^ c) + 2 ^ c) + 3
    clrf    BH
    xorwf   BL, F
    xorwf   BL, F
    incf    BL, F
    xorwf   BL, F
    incf    BL, F
    incf    BL, F
    xorwf   BL, F
    movlw   3
    addwf   BL, F

    point_fsr0 names
    movlw   AL + 2
    call    result16
    call    result16_next

    movf    AL, W           ; a == 0xF4
    xorlw   0xF4
    exit_code_from_z
    bench_exit

; W = CRC = CRC-8 of the W bytes at FSR0. Uses FSR1.
crc8:
    movwf   N
    clrf    CRC
1:
    moviw   FSR0++
    xorwf   CRC, W
    addlw   lo8(table)      ; FSR1 = table + index
    movwf   FSR1L
    movlw   hi8(table)
    btfsc   STATUS, C
    movlw   hi8(table + 256)
    movwf   FSR1H
    movf    INDF1, W
    movwf   CRC
    decfsz  N, F
    bra     1b
    clrf    FSR1H           ; for result16
    return

    bench_io
    bench_result16

    .section .rodata,"a",@progbits
table:
    .byte   0x00, 0x07, 0x0E, 0x09, 0x1C, 0x1B, 0x12, 0x15, 0x38, 0x3F, 0x36, 0x31, 0x24, 0x23, 0x2A, 0x2D
    .byte   0x70, 0x77, 0x7E, 0x79, 0x6C, 0x6B, 0x62, 0x65, 0x48, 0x4F, 0x46, 0x41, 0x54, 0x53, 0x5A, 0x5D
    .byte   0xE0, 0xE7, 0xEE, 0xE9, 0xFC, 0xFB, 0xF2, 0xF5, 0xD8, 0xDF, 0xD6, 0xD1, 0xC4, 0xC3, 0xCA, 0xCD
    .byte   0x90, 0x97, 0x9E, 0x99, 0x8C, 0x8B, 0x82, 0x85, 0xA8, 0xAF, 0xA6, 0xA1, 0xB4, 0xB3, 0xBA, 0xBD
    .byte   0xC7, 0xC0, 0xC9, 0xCE, 0xDB, 0xDC, 0xD5, 0xD2, 0xFF, 0xF8, 0xF1, 0xF6, 0xE3, 0xE4, 0xED, 0xEA
    .byte   0xB7, 0xB0, 0xB9, 0xBE, 0xAB, 0xAC, 0xA5, 0xA2, 0x8F, 0x88, 0x81, 0x86, 0x93, 0x94, 0x9D, 0x9A
    .byte   0x27, 0x20, 0x29, 0x2E, 0x3B, 0x3C, 0x35, 0x32, 0x1F, 0x18, 0x11, 0x16, 0x03, 0x04, 0x0D, 0x0A
    .byte   0x57, 0x50, 0x59, 0x5E, 0x4B, 0x4C, 0x45, 0x42, 0x6F, 0x68, 0x61, 0x66, 0x73, 0x74, 0x7D, 0x7A
    .byte   0x89, 0x8E, 0x87, 0x80, 0x95, 0x92, 0x9B, 0x9C, 0xB1, 0xB6, 0xBF, 0xB8, 0xAD, 0xAA, 0xA3, 0xA4
    .byte   0xF9, 0xFE, 0xF7, 0xF0, 0xE5, 0xE2, 0xEB, 0xEC, 0xC1, 0xC6, 0xCF, 0xC8, 0xDD, 0xDA, 0xD3, 0xD4
    .byte   0x69, 0x6E, 0x67, 0x60, 0x75, 0x72, 0x7B, 0x7C, 0x51, 0x56, 0x5F, 0x58, 0x4D, 0x4A, 0x43, 0x44
    .byte   0x19, 0x1E, 0x17, 0x10, 0x05, 0x02, 0x0B, 0x0C, 0x21, 0x26, 0x2F, 0x28, 0x3D, 0x3A, 0x33, 0x34
    .byte   0x4E, 0x49, 0x40, 0x47, 0x52, 0x55, 0x5C, 0x5B, 0x76, 0x71, 0x78, 0x7F, 0x6A, 0x6D, 0x64, 0x63
    .byte   0x3E, 0x39, 0x30, 0x37, 0x22, 0x25, 0x2C, 0x2B, 0x06, 0x01, 0x08, 0x0F, 0x1A, 0x1D, 0x14, 0x13
    .byte   0xAE, 0xA9, 0xA0, 0xA7, 0xB2, 0xB5, 0xBC, 0xBB, 0x96, 0x91, 0x98, 0x9F, 0x8A, 0x8D, 0x84, 0x83
    .byte   0xDE, 0xD9, 0xD0, 0xD7, 0xC2, 0xC5, 0xCC, 0xCB, 0xE6, 0xE1, 0xE8, 0xEF, 0xFA, 0xFD, 0xF4, 0xF3
check:
    .ascii  "123456789"
names:
    .asciz  "check="
    .asciz  "table="
